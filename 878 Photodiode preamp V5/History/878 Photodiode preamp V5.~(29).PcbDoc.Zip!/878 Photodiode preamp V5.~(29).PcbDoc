# Altium PCB 878 Photodiode preamp V5.~(29).PcbDoc (part 2 of 2)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 114 x 114 mm, 6 copper layers (Top Layer, Internal Plane 1, Dummy Ground, Dummy Power, Internal Plane 2, Bottom Layer), stack 0.534 mm thick; 182 components, 80 nets, 485 pads, 76 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 1.27, hole 0.8, Top Layer to Bottom Layer, 42 vias
v2: diameter 1.27, hole 0.711, Top Layer to Bottom Layer, 34 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetC11_1: C11.1 C14.1 D4.2 D6.1 L2.1 L4.2 R8.1 | length 67
  Top Layer w0.305: L2.1@132.08,120.65 v2(135.255,120.65)
  Top Layer w0.508: L4.2@141.065,89.535 141.065,92.488 139.065,94.488 D4.2@139.065,97.93 140.83,97.93 141.605,98.705 141.605,102.235 142.24,102.87 D6.1@144.285,102.87 ; D6.1@144.145,102.73 D6.1@144.285,102.87 ; C11.1@154.675,100.965 154.642,100.998 154.642,102.87 ; C14.1@154.675,113.03 154.642,112.997 154.642,102.87 ; D6.1@144.285,102.87 R8.1@151.892,102.87 154.642,102.87
  Bottom Layer w0.305: v2(135.255,120.65) 142.875,113.03 C14.1@154.675,113.03
NetC11_2: C11.2 C14.2 R11.1 | length 24.6
  Top Layer w0.305: R11.1@151.892,111.252 151.892,114.427 152.4,114.935 158.75,114.935 159.675,114.01 C14.2@159.675,113.03 C11.2@159.675,100.965
NetC12_1: C12.1 C16.1 R12.2 | length 20.6
  Top Layer w0.305: R12.2@151.13,132.715 159.675,132.715 ; C16.1@159.675,126.365 159.675,132.715 ; C12.1@159.675,138.43 159.675,132.715
NetC12_2: C12.2 C16.2 R6.1 R9.2 R50.1 U4.2 | length 44.2
  Top Layer w0.305: U4.2@140.017,135.89 137.795,135.89 v1(137.16,136.525) 137.16,139.065 137.795,139.7 R50.1@139.065,139.7 R6.1@141.605,139.7 ; R9.2@151.765,125.095 153.405,125.095 C16.2@154.675,126.365
  Bottom Layer w0.305: v1(137.16,136.525) 137.795,137.16 152.4,137.16 153.67,138.43 C12.2@154.675,138.43 C16.2@154.675,126.365
NetC13_1: C13.1 R10.1 R13.2 U2.2 | length 16.6
  Top Layer w0.305: R13.2@110.49,156.21 U2.2@113.347,156.21 114.935,156.21 115.57,156.845 115.57,159.385 113.03,161.925 C13.1@113.03,164.465 R10.1@113.03,167.005
NetC13_2: C13.2 R14.1 U2.1 | length 10.7
  Top Layer w0.305: R14.1@110.49,167.005 C13.2@110.49,164.465 110.49,162.56 113.347,159.702 U2.1@113.347,157.48
NetC20_1: C20.1 R15.1 R16.1 U5.2 | length 11.2
  Top Layer w0.305: U5.2@136.207,156.21 137.414,156.21 137.922,156.718 137.922,157.988 137.414,158.496 136.906,158.496 136.525,158.877 R16.1@136.525,160.02 C20.1@136.525,162.56 R15.1@136.525,165.1
NetC20_2: C20.2 R16.2 R18.1 R22.1 U5.6 U6.5 X7.1 | length 45.8
  Top Layer w0.305: R22.1@121.92,153.67 121.92,147.955 122.555,147.32 130.81,147.32 131.445,147.955 131.445,149.225 ; U6.5@130.493,153.67 130.493,153.352 131.445,152.4 R18.1@131.445,151.13 131.445,149.225 ; C20.2@139.065,162.56 R16.2@139.065,160.02 139.065,156.591 140.716,154.94 ; U5.6@141.922,154.94 140.716,154.94 ; 131.445,149.225 139.7,149.225 140.462,149.987 140.462,154.686 140.716,154.94
NetC21_2: C21.2 R15.2 | length 28.6
  Top Layer w0.305: R15.2@139.065,165.1 139.065,167.513 v1(139.192,167.64)
  Bottom Layer w0.305: v1(139.192,167.64) 142.24,167.64 146.05,163.83 148.336,163.83 149.606,162.56 149.606,153.924 147.65,151.968 C21.2@147.65,149.9
NetC23_1: C23.1 R17.1 R18.2 U6.6 | length 18.8
  Top Layer w0.305: R17.1@125.73,167.005 C23.1@125.73,164.465 125.73,160.655 127.635,158.75 127.635,156.21 128.905,154.94 ; R18.2@128.905,151.13 128.905,154.94 ; U6.6@130.493,154.94 128.905,154.94
NetC23_2: C23.2 R19.1 U6.7 | length 12.6
  Top Layer w0.305: R19.1@128.27,167.005 C23.2@128.27,164.465 128.27,156.845 128.905,156.21 U6.7@130.493,156.21
NetC25_2: C25.2 R20.1 R24.2 U5.3 | length 26.5
  Top Layer w0.305: U5.3@136.843,154.94 v1(139.065,154.94) ; R20.1@141.605,162.56 147.32,162.56 148.59,161.29 149.352,161.29 149.86,160.782 R24.2@149.86,158.242
  Bottom Layer w0.305: v1(139.065,154.94) 143.8,154.94 147.65,158.79 C25.2@147.65,161.33
NetC26_1: C26.1 R21.1 R22.2 U6.2 | length 17.1
  Top Layer w0.305: R22.2@121.92,156.21 U6.2@124.777,156.21 126.365,156.21 127,156.845 127,158.115 125.095,160.02 125.095,162.56 C26.1@123.19,164.465 R21.1@123.19,167.005
NetC26_2: C26.2 R23.1 U6.1 | length 12.4
  Top Layer w0.305: R23.1@120.65,167.005 C26.2@120.65,164.465 120.65,163.195 121.285,162.56 123.19,162.56 123.825,161.925 123.825,159.385 124.777,158.433 U6.1@124.777,157.48
NetC28_1: C28.1 D8.2 D10.2 L5.2 | length 13.2
  Top Layer w1.016: C28.1@91.44,183.515 91.44,186.411 L5.2@91.161,186.69 D10.2@95.39,186.69 95.39,185.28 97.79,182.88 D8.2@98.665,182.88
NetC29_1: C29.1 D9.1 D11.2 L6.2 | length 12
  Top Layer w1.27: D9.1@117.235,183.515 118.745,183.515 119.38,182.88 D11.2@121.425,182.88 121.425,185.915 C29.1@120.65,186.69 L6.2@124.104,186.69
NetC30_2: C30.2 U7.1 | length 3.6
  Top Layer w0.635: U7.1@92.71,104.953 C30.2@92.71,108.585
NetC32_1: C32.1 L7.1 U7.3 | length 7.8
  Top Layer w0.635: C32.1@92.71,95.25 U7.3@92.71,99.517
  Top Layer w0.762: L7.1@89.154,95.25 C32.1@92.71,95.25
NetC32_2: C32.2 J2.1 X12.1 | length 12.9
  Top Layer w0.635: X12.1@86.055,85.725 J2.1@92.558,85.725 92.71,85.877 C32.2@92.71,92.075
NetC35_1: C35.1 R29.1 R32.2 R35.2 R51.1 U9.2 | length 23.2
  Top Layer w0.305: R35.2@67.31,117.475 69.215,117.475 ; U9.2@71.438,117.475 69.215,117.475 ; C35.1@73.025,127.635 R51.1@73.025,125.095 R29.1@73.025,122.555 R29.1@69.215,122.555 69.215,117.475
  Top Layer w1.016: R32.2@67.31,112.395 R35.2@67.31,117.475
NetC35_2: C35.2 R29.2 R33.1 R36.1 R51.2 U9.6 X15.1 | length 35.8
  Top Layer w0.305: R36.1@64.135,132.08 R33.1@64.135,128.905 66.675,128.905 67.31,128.27 ; X15.1@67.31,127 67.31,128.27 ; U9.6@77.153,116.205 75.565,116.205 74.93,116.84 74.93,120.015 75.565,120.65 ; R29.2@79.375,122.555 77.47,120.65 75.565,120.65 ; 67.31,128.27 67.945,128.905 75.565,128.905 C35.2@75.565,127.635 R51.2@75.565,125.095 R29.2@75.565,122.555 75.565,120.65
NetC36_1: C36.1 R52.2 | length 2.5
  Top Layer w0.305: R52.2@70.485,142.24 C36.1@73.025,142.24
NetC36_2: C36.2 R28.1 R30.2 R37.1 U8.5 U10.6 X14.1 | length 60.5
  Top Layer w0.305: U10.6@77.153,134.62 75.565,134.62 74.93,135.255 74.93,137.795 75.565,138.43 R30.2@75.565,139.7 C36.2@75.565,142.24 75.565,144.145 76.835,145.415 93.345,145.415 95.885,147.955 ; R37.1@96.52,153.67 96.52,149.86 95.885,149.225 95.885,147.955 ; U8.5@105.093,153.67 106.68,153.67 106.68,151.13 ; R28.1@105.41,151.13 106.68,151.13 ; 95.885,147.955 96.52,147.32 101.6,147.32 X14.1@102.87,146.05 102.87,146.685 104.14,147.955 106.045,147.955 106.68,148.59 106.68,151.13
NetC37_1: C37.1 R27.1 R28.2 U8.6 | length 18.6
  Top Layer w0.305: R28.2@102.87,151.13 102.87,154.94 ; R27.1@102.87,167.005 C37.1@102.87,164.465 102.87,161.925 102.235,161.29 102.235,155.575 102.87,154.94 ; U8.6@105.093,154.94 102.87,154.94
NetC37_2: C37.2 R31.1 U8.7 | length 13.7
  Top Layer w0.305: U8.7@105.093,156.21 103.505,156.21 102.87,156.845 102.87,160.655 105.41,163.195 C37.2@105.41,164.465 R31.1@105.41,167.005
NetC40_1: C40.1 C43.1 D15.2 D17.1 L8.1 L10.2 R32.1 | length 74.5
  Top Layer w1.016: C43.1@55.92,100.965 55.92,110.49 ; C40.1@55.92,113.03 55.92,110.49 ; R32.1@64.77,112.395 64.77,110.49 ; L10.2@77.07,89.535 77.07,93.745 73.66,97.155 D15.2@73.66,101.74 71.615,101.74 71.12,102.235 71.12,105.41 69.99,106.54 ; L8.1@86.995,114.3 86.995,112.395 84.455,109.855 72.39,109.855 69.99,107.455 69.99,106.54 ; 55.92,110.49 64.77,110.49 ; 64.77,110.49 64.77,107.315 65.545,106.54 D17.1@67.945,106.54 69.99,106.54
NetC40_2: C40.2 C43.2 R35.1 | length 19.6
  Top Layer w1.016: C40.2@60.92,113.03 60.92,116.165 62.23,117.475 R35.1@64.77,117.475
  Bottom Layer w1.016: C43.2@60.92,100.965 C40.2@60.92,113.03
NetC41_1: C41.1 C45.1 R36.2 | length 20.3
  Top Layer w0.305: C45.1@55.92,126.365 55.92,134.62 ; C41.1@55.92,138.43 55.92,134.62 ; R36.2@64.135,134.62 55.92,134.62
NetC41_2: C41.2 C45.2 R30.1 R33.2 R52.1 U10.2 | length 34.4
  Top Layer w0.305: C45.2@60.92,126.365 R33.2@64.135,126.365 ; C41.2@60.92,138.43 64.77,138.43 67.31,135.89 U10.2@71.438,135.89 72.39,135.89 73.025,136.525 R30.1@73.025,139.7 R52.1@70.485,139.7
  Bottom Layer w0.305: C45.2@60.92,126.365 C41.2@60.92,138.43
NetC42_1: C42.1 R34.1 R37.2 U8.2 | length 15.1
  Top Layer w0.305: R37.2@96.52,156.21 U8.2@99.377,156.21 100.33,156.21 100.965,156.845 100.965,163.83 C42.1@100.33,164.465 R34.1@100.33,167.005
NetC42_2: C42.2 R38.1 U8.1 | length 10.8
  Top Layer w0.305: R38.1@97.79,167.005 C42.2@97.79,164.465 97.79,163.195 98.425,162.56 99.06,162.56 99.695,161.925 99.695,157.797 U8.1@99.377,157.48
NetC49_1: C49.1 R39.1 R40.1 U11.2 | length 25.2
  Top Layer w0.305: v1(80.01,164.465) 80.01,163.195 80.645,162.56 81.915,162.56 C49.1@84.455,162.56
  Top Layer w0.762: v1(70.485,160.02) 69.85,159.385 R39.1@69.85,158.115 69.85,156.845 70.485,156.21 U11.2@73.977,156.21
  Bottom Layer w0.762: v1(70.485,160.02) 74.93,164.465 v1(80.01,164.465)
NetC49_2: C49.2 R40.2 R42.1 R46.1 U11.6 U12.5 X17.1 | length 36
  Top Layer w0.305: U11.6@80.328,154.94 81.915,154.94 ; R40.2@81.915,160.02 84.455,160.02 84.455,157.48 82.55,157.48 81.915,156.845 81.915,154.94 ; X17.1@86.69,147.955 84.455,147.955 83.82,148.59 83.82,152.4 81.915,154.305 81.915,154.94
  Top Layer w0.762: X17.1@86.69,147.955 87.63,147.955 88.9,146.685 92.075,146.685 94.615,149.225 R42.1@94.615,151.13 94.615,152.4 93.662,153.352 U12.5@93.662,153.67
NetC50_2: C50.2 R39.2 | length 3.5
  Top Layer w0.762: R39.2@67.31,158.115 67.31,155.575 67.945,154.94 C50.2@67.945,154.9
NetC52_1: C52.1 R41.1 R42.2 U12.6 | length 19.3
  Top Layer w0.305: 92.075,154.94 90.805,156.21 90.805,160.655 92.71,162.56 C52.1@92.71,164.465 R41.1@92.71,167.005
  Top Layer w0.762: R42.2@92.075,151.13 92.075,152.4 91.44,153.035 91.44,154.305 92.075,154.94 U12.6@93.662,154.94
NetC52_2: C52.2 R43.1 U12.7 | length 14.2
  Top Layer w0.305: U12.7@93.662,156.21 92.075,156.21 91.44,156.845 91.44,159.385 95.25,163.195 C52.2@95.25,164.465 R43.1@95.25,167.005
NetC54_2: C54.2 R44.1 R48.2 U11.3 | length 22.7
  Top Layer w0.305: U11.3@73.977,154.94 75.565,154.94 ; R44.1@74.93,163.195 74.93,159.385 76.2,158.115 76.2,155.575 75.565,154.94 ; R48.2@76.835,151.13 76.835,153.67 75.565,154.94
  Top Layer w0.762: C54.2@67.945,161.33 69.261,161.33 70.796,162.865 74.6,162.865 R44.1@74.93,163.195
NetC55_1: C55.1 R45.1 R46.2 U12.2 | length 16.7
  Top Layer w0.305: R46.2@84.455,154.94 85.09,154.94 86.36,156.21 U12.2@87.947,156.21 89.535,156.21 90.17,156.845 C55.1@90.17,164.465
  Top Layer w0.762: C55.1@90.17,164.465 R45.1@90.17,167.005
NetC55_2: C55.2 R47.1 U12.1 | length 9.7
  Top Layer w0.762: R47.1@87.63,167.005 C55.2@87.63,164.465 87.63,161.925 87.947,161.607 U12.1@87.947,157.48
NetD4_K: D4.1 D5.2 | length 9.1
  Top Layer w1.016: D5.2@133.985,97.93 135.75,97.93 136.525,98.705 136.525,102.235 137.02,102.73 D4.1@139.065,102.73
NetD5_K: D5.1 D7.2 | length 4.7
  Top Layer w1.016: D5.1@133.985,102.73 D7.2@133.985,107.455
NetD15_K: D15.1 D16.2 | length 8.6
  Top Layer w1.016: D15.1@73.66,106.54 75.07,106.54 76.2,105.41 76.2,102.87 77.33,101.74 D16.2@78.74,101.74
NetD16_K: D16.1 D18.2 | length 8.4
  Top Layer w1.016: D16.1@78.74,106.54 78.88,106.68 80.01,106.68 81.28,105.41 81.28,102.235 81.775,101.74 D18.2@83.185,101.74
NetL1_2: L1.2 R2.1 | length 3.2
  Top Layer w0.508: L1.2@125.73,92.075 R2.1@128.905,92.075
NetL7_2: L7.2 R26.1 | length 3.1
  Top Layer w0.762: R26.1@86.106,92.202 89.027,92.202 L7.2@89.154,92.075
NetR1_1: R1.1 RL1.6 X1.1 | length 13.2
  Top Layer w0.635: RL1.6@122.301,116.332 124.587,116.332 126.365,118.11 X1.1@126.365,121.92 126.365,123.825 R1.1@128.27,125.73
NetR25_1: R25.1 RL2.6 X11.1 | length 25.2
  Top Layer w0.635: X11.1@89.23,121.92 89.23,124.79 R25.1@89.535,125.095 ; R25.1@89.535,124.46 92.075,124.46 92.71,123.825 97.155,123.825 98.425,122.555 100.33,122.555 102.235,120.65 102.235,116.84 102.743,116.332 RL2.6@105.791,116.332
OUT1+: J3.9 R3.2 R7.2 | length 22.1
  Top Layer w0.305: R3.2@115.57,169.545 v1(115.57,171.45)
  Top Layer w0.762: R3.2@115.57,169.545 R7.2@118.11,169.545
  Bottom Layer w0.305: J3.9@102.26,176.068 102.26,174.6 107.315,169.545 113.665,169.545 v1(115.57,171.45)
OUT1-: J3.21 R10.2 R14.2 | length 16.1
  Top Layer w0.305: R14.2@110.49,169.545 v1(110.49,170.815)
  Top Layer w0.762: R14.2@110.49,169.545 R10.2@113.03,169.545
  Bottom Layer w0.203: 103.645,175.26 J3.21@103.645,178.913
  Bottom Layer w0.305: 103.645,175.26 108.09,170.815 v1(110.49,170.815)
OUT2+: J3.13 R27.2 R31.2 | length 19.1
  Top Layer w0.305: R27.2@102.87,169.545 v1(102.87,171.45)
  Top Layer w0.762: R27.2@102.87,169.545 R31.2@105.41,169.545
  Bottom Layer w0.305: J3.13@91.186,176.068 91.186,174.244 92.075,173.355 99.06,173.355 100.965,171.45 v1(102.87,171.45)
OUT2-: J3.25 R34.2 R38.2 | length 21.4
  Top Layer w0.305: R38.2@97.79,169.545 v1(97.79,171.45)
  Top Layer w0.762: R38.2@97.79,169.545 99.06,169.545 R34.2@100.33,169.545
  Bottom Layer w0.305: J3.25@92.57,178.913 90.648,178.913 89.535,177.8 89.535,173.99 90.805,172.72 97.155,172.72 97.79,172.085 v1(97.79,171.45)
PHOTODIODE1_PIN1: C1.1 D1.2 J4.5 L2.2 R1.2 | length 58.3
  Top Layer w0.508: J4.5@113.335,134.62 113.335,137.465 114.3,138.43 124.46,138.43 125.73,137.16 125.73,132.715 126.365,132.08 132.08,132.08 132.08,123.825 129.54,123.825 128.905,123.19 128.905,111.76 C1.1@125.73,108.585 ; R1.2@128.27,128.27 D1.2@128.27,131.685
PHOTODIODE1_PIN2: C5.1 C25.1 D1.1 D2.1 D3.1 J4.4 L3.2 R20.2 X6.1 | length 111
  Top Layer w0.305: 138.43,169.545 L3.2@138.43,171.45
  Top Layer w0.508: J4.4@110.566,134.62 110.566,137.236 113.03,139.7 127,139.7 128.27,138.43 D1.1@128.27,136.285 ; X6.1@132.554,166.37 132.588,166.404 132.588,168.148 v1(135.128,168.148) 136.398,168.148 137.795,169.545 138.43,169.545 C5.1@141.605,169.545 142.875,169.545 ; D3.1@138.43,179.04 139.59,180.2 D2.1@141.605,180.2 143.65,180.2 144.069,179.781 144.069,170.739 142.875,169.545 ; D2.1@141.11,179.07 D2.1@141.605,179.565 ; R20.2@141.605,165.1 141.605,166.243 141.732,166.37 143.51,166.37 ; C25.1@147.65,166.33 147.61,166.37 143.51,166.37 ; 142.875,169.545 143.51,168.91 143.51,166.37
  Bottom Layer w0.508: J4.4@110.566,134.62 110.566,140.411 132.588,162.433 132.588,166.116 134.62,168.148 v1(135.128,168.148)
PHOTODIODE2_PIN1: C30.1 D12.2 J4.2 L8.2 R25.2 | length 59.2
  Top Layer w0.635: C30.1@90.17,108.585 90.17,116.205 88.9,117.475 86.995,117.475 86.995,131.685 86.755,131.445 85.09,131.445 85.09,138.43 86.36,139.7 103.505,139.7 105.029,138.176 J4.2@105.029,134.62
PHOTODIODE2_PIN2: C34.1 C54.1 D12.1 D13.1 D14.1 J4.1 L9.2 R44.2 X16.1 | length 91.5
  Top Layer w0.635: C54.1@67.945,166.33 72.43,166.33 73.025,165.735 R44.2@74.93,165.735 77.47,165.735 78.105,166.37 ; D13.1@71.12,174.485 77.61,174.485 78.105,173.99 C34.1@78.105,170.815 78.105,166.37 ; v1(86.106,162.306) 86.106,162.56 85.852,162.814 85.852,165.354 84.836,166.37 X16.1@83.041,166.37 78.105,166.37 ; D12.1@86.995,136.285 86.995,137.795 87.63,138.43 100.965,138.43 102.26,137.135 J4.1@102.26,134.62
  Bottom Layer w0.635: v1(86.106,162.306) 86.487,162.306 92.075,156.718 92.075,151.13 102.26,140.945 J4.1@102.26,134.62
RLY1: D19.1 J3.18 RL1.1 | length 122.3
  Top Layer w0.635: D19.1@111.125,118.605 111.366,118.364 RL1.1@115.189,118.364 ; RL1.1@115.824,118.364 116.205,118.745 v1(116.205,121.285)
  Bottom Layer w0.635: J3.18@111.95,178.913 111.95,179.895 114.3,182.245 137.16,182.245 150.114,169.291 150.114,164.084 150.876,163.322 150.876,144.272 147.574,140.97 136.525,140.97 116.84,121.285 v1(116.205,121.285)
RLY2: D20.1 J3.22 RL2.1 | length 87.9
  Top Layer w0.635: v1(95.25,121.92) 94.615,121.285 D20.1@94.615,118.605 98.438,118.605 RL2.1@98.679,118.364
  Bottom Layer w0.635: v1(95.25,121.92) 95.25,122.555 89.535,128.27 89.535,142.24 86.677,145.097 86.677,157.162 83.82,160.02 83.82,161.925 83.185,162.56 83.185,167.64 88.425,172.88 88.425,179.23 90.805,181.61 100.152,181.61 100.876,180.886 J3.22@100.876,178.913
TEST+: J3.2 R53.2 U13.3 | length 64.8
  Top Layer w0.305: J3.2@121.641,176.068 123.05,177.478 125.408,177.478 130.175,182.245 143.51,182.245 144.78,180.975 144.78,171.45 147.32,168.91 148.844,168.91 152.908,164.846 R53.2@154.432,164.846 154.305,164.719 154.305,156.845 151.765,154.305 151.765,151.765 152.4,151.13 U13.3@153.987,151.13
TEST-: J3.14 R54.2 U13.2 | length 69.3
  Top Layer w0.305: J3.14@123.025,178.913 125.573,178.913 129.54,182.88 144.145,182.88 145.415,181.61 145.415,172.085 147.32,170.18 157.226,170.18 158.75,168.656 158.75,165.354 158.242,164.846 R54.2@156.972,164.846 156.464,164.338 156.464,163.322 155.575,162.433 155.575,155.575 156.21,154.94 156.21,153.035 155.575,152.4 U13.2@153.987,152.4
TESTSIG: RL1.5 RL2.5 U13.6 | length 115.5
  Top Layer w0.635: RL2.5@98.679,116.332 98.679,112.776 100.33,111.125 114.3,111.125 115.189,112.014 v1(115.189,113.03) RL1.5@115.189,116.332 ; v1(157.48,142.24) 161.29,142.24 161.925,142.875 161.925,150.495 161.29,151.13 U13.6@159.702,151.13
  Bottom Layer w0.635: v1(115.189,113.03) 128.27,113.03 131.445,109.855 156.21,109.855 157.48,111.125 v1(157.48,142.24)
pads on no net: U3.1 U3.5 U3.8 U4.1 U4.5 U4.8 U5.1 U5.5 U5.8 U9.1 U9.5 U9.8 U10.1 U10.5 U10.8 U11.1 U11.5 U11.8 U13.1 U13.8

## Polygon pours and split planes (outlines as drawn)
-15V on Dummy Power "Top Layer-No Net" (solid, remove dead copper, pour order 4): 51.435,189.23 163.83,189.23 163.83,76.835 51.435,76.835
+15V on Dummy Power "+15V_L04_P006" (solid, remove dead copper, pour order 6): 51.435,189.23 163.83,189.23 163.83,76.835 51.435,76.835
GND on Dummy Ground "Top Layer-No Net" (solid, remove dead copper, pour order 2): 51.435,189.23 163.83,189.23 163.83,76.835 51.435,76.835
GND on Bottom Layer "Top Layer-No Net" (solid, remove dead copper, pour order 0): 51.435,76.835 163.83,76.835 163.83,189.23 51.435,189.23
GND on Top Layer "Top Layer-GND" (solid, remove dead copper, pour order 8): 51.435,76.835 164.465,76.835 164.465,189.865 51.435,189.865

## Keep-outs
Keep-Out Layer:
  lines w0.127: 69.85,183.134 79.248,183.134 79.248,186.182 69.85,186.182 69.85,183.134
  lines w0.254: 50.8,91.288 ccw(c65.888,91.288) 65.888,76.2 149.708,76.2 ccw(c149.708,91.288) 164.795,91.288 164.795,175.108 ccw(c149.708,175.108) 149.708,190.195 65.888,190.195 ccw(c65.888,175.108) 50.8,175.108 50.8,91.288

## Other copper
Top Layer:
  region: 113.135,81.822 113.205,81.822 113.205,81.751 113.276,81.751 113.276,81.681 113.346,81.681 113.346,81.611 113.416,81.611 113.416,81.541 113.416,81.47 113.416,81.4 113.487,81.4 113.487,81.33 113.487,81.259 113.135,81.259 113.135,81.33 113.135,81.4 113.135,81.47 113.135,81.541 113.135,81.611 113.135,81.681 113.135,81.751 113.065,81.751 113.065,81.822 113.065,81.892 113.135,81.892
  region: 103.715,82.103 103.715,82.033 103.715,81.962 103.786,81.962 103.786,81.892 103.786,81.822 103.856,81.822 103.856,81.751 103.856,81.681 103.856,81.611 103.364,81.611 103.364,81.681 103.434,81.681 103.434,81.751 103.505,81.751 103.505,81.822 103.505,81.892 103.505,81.962 103.575,81.962 103.575,82.033 103.575,82.103 103.645,82.103 103.645,82.173 103.715,82.173
  region: 101.677,85.126 101.817,85.126 101.817,85.055 101.888,85.055 101.888,84.985 101.888,84.915 101.888,84.844 101.888,84.774 101.817,84.774 101.817,84.704 101.747,84.704 101.747,84.634 101.466,84.634 101.466,84.704 101.466,84.774 101.466,84.844 101.466,84.915 101.466,84.985 101.466,85.055 101.466,85.126 101.466,85.196 101.677,85.196
  region: 103.153,85.126 103.294,85.126 103.294,85.055 103.294,84.985 103.364,84.985 103.364,84.915 103.364,84.844 103.294,84.844 103.294,84.774 103.294,84.704 103.153,84.704 103.153,84.634 102.942,84.634 102.942,84.704 102.942,84.774 102.942,84.844 102.942,84.915 102.942,84.985 102.942,85.055 102.942,85.126 102.942,85.196 103.153,85.196
  region: 108.847,89.203 108.988,89.203 108.988,89.133 108.988,89.062 109.058,89.062 109.058,88.992 109.058,88.922 108.988,88.922 108.988,88.851 108.917,88.851 108.917,88.781 108.777,88.781 108.777,88.711 108.636,88.711 108.636,88.781 108.636,88.851 108.636,88.922 108.636,88.992 108.636,89.062 108.636,89.133 108.636,89.203 108.636,89.273 108.847,89.273
  region: 103.856,92.226 103.856,92.155 103.926,92.155 103.926,92.085 103.926,92.015 103.926,91.944 103.997,91.944 103.997,91.874 103.997,91.804 104.067,91.804 104.067,91.733 103.575,91.733 103.575,91.804 103.575,91.874 103.645,91.874 103.645,91.944 103.645,92.015 103.645,92.085 103.715,92.085 103.715,92.155 103.715,92.226 103.786,92.226 103.786,92.296 103.856,92.296
  region: 215 vertices and 17 holes, not listed, extent 99.568,86.883 115.525,94.334
  region: 215 vertices and 15 holes, not listed, extent 99.568,79.01 115.525,86.461
  region: 108.496,92.928 108.706,92.928 108.706,92.858 108.917,92.858 108.917,92.788 108.988,92.788 108.988,92.718 109.058,92.718 109.058,92.647 109.128,92.647 109.128,92.577 109.128,92.507 109.199,92.507 109.199,92.436 109.199,92.366 109.269,92.366 109.269,92.296 109.269,92.226 109.269,92.155 109.269,92.085 109.269,92.015 109.339,92.015 109.339,91.944 109.339,91.874 109.269,91.874 109.269,91.804 109.269,91.733 109.269,91.663 109.269,91.593 109.269,91.523 109.199,91.523 109.199,91.452 109.199,91.382 109.199,91.312 109.128,91.312 109.128,91.241 109.058,91.241 109.058,91.171 108.988,91.171 108.988,91.101 108.917,91.101 108.917,91.031 108.777,91.031 108.777,90.96 108.566,90.96 108.566,90.89 108.003,90.89 108.003,90.96 108.003,91.031 108.003,91.101 108.003,91.171 108.003,91.241 107.933,91.241 107.933,91.312 107.933,91.382 107.933,91.452 107.933,91.523 107.933,91.593 107.933,91.663 107.933,91.733 107.933,91.804 107.933,91.874 107.933,91.944 107.933,92.015 107.933,92.085 107.933,92.155 107.933,92.226 107.933,92.296 107.933,92.366 107.933,92.436 107.933,92.507 108.003,92.507 108.003,92.577 108.003,92.647 108.003,92.718 108.003,92.788 108.003,92.858 108.003,92.928 108.003,92.999 108.496,92.999
  region: 109.269,82.806 109.48,82.806 109.48,82.736 109.62,82.736 109.62,82.665 109.761,82.665 109.761,82.595 109.831,82.595 109.831,82.525 109.901,82.525 109.901,82.454 109.901,82.384 109.972,82.384 109.972,82.314 109.972,82.244 110.042,82.244 110.042,82.173 110.042,82.103 110.042,82.033 110.042,81.962 110.042,81.892 110.112,81.892 110.112,81.822 110.112,81.751 110.042,81.751 110.042,81.681 110.042,81.611 110.042,81.541 110.042,81.47 110.042,81.4 109.972,81.4 109.972,81.33 109.972,81.259 109.901,81.259 109.901,81.189 109.901,81.119 109.831,81.119 109.831,81.049 109.761,81.049 109.761,80.978 109.691,80.978 109.691,80.908 109.55,80.908 109.55,80.838 109.269,80.838 109.269,80.767 108.777,80.767 108.777,80.838 108.777,80.908 108.777,80.978 108.777,81.049 108.706,81.049 108.706,81.119 108.706,81.189 108.706,81.259 108.706,81.33 108.706,81.4 108.706,81.47 108.706,81.541 108.706,81.611 108.706,81.681 108.706,81.751 108.706,81.822 108.706,81.892 108.706,81.962 108.706,82.033 108.706,82.103 108.706,82.173 108.706,82.244 108.706,82.314 108.706,82.384 108.777,82.384 108.777,82.454 108.777,82.525 108.777,82.595 108.777,82.665 108.777,82.736 108.777,82.806 108.777,82.876 109.269,82.876
  region: 113.346,82.876 113.697,82.876 113.697,82.806 113.838,82.806 113.838,82.736 113.908,82.736 113.908,82.665 113.979,82.665 113.979,82.595 114.049,82.595 114.049,82.525 114.119,82.525 114.119,82.454 114.119,82.384 114.119,82.314 114.19,82.314 114.19,82.244 114.119,82.244 114.119,82.173 114.19,82.173 114.19,82.103 114.19,82.033 114.19,81.962 114.119,81.962 114.119,81.892 114.19,81.892 114.19,81.822 114.119,81.822 114.119,81.751 114.119,81.681 114.049,81.681 114.049,81.611 114.049,81.541 114.049,81.47 113.979,81.47 113.979,81.4 113.908,81.4 113.908,81.47 113.908,81.541 113.908,81.611 113.838,81.611 113.838,81.681 113.838,81.751 113.768,81.751 113.768,81.822 113.768,81.892 113.697,81.892 113.697,81.962 113.627,81.962 113.627,82.033 113.487,82.033 113.487,82.103 113.346,82.103 113.346,82.173 113.065,82.173 113.065,82.244 113.065,82.314 113.135,82.314 113.135,82.384 113.135,82.454 113.135,82.525 113.135,82.595 113.135,82.665 113.135,82.736 113.135,82.806 113.135,82.876 113.276,82.876 113.276,82.946 113.346,82.946
  region: 106.176,92.928 106.316,92.928 106.316,92.858 106.387,92.858 106.387,92.788 106.457,92.788 106.457,92.718 106.457,92.647 106.457,92.577 106.457,92.507 106.527,92.507 106.527,92.436 106.527,92.366 106.457,92.366 106.457,92.296 106.457,92.226 106.457,92.155 106.387,92.155 106.387,92.085 106.387,92.015 106.316,92.015 106.316,91.944 106.246,91.944 106.246,91.874 106.035,91.874 106.035,91.804 105.613,91.804 105.613,91.874 105.613,91.944 105.613,92.015 105.613,92.085 105.613,92.155 105.613,92.226 105.613,92.296 105.613,92.366 105.613,92.436 105.613,92.507 105.613,92.577 105.613,92.647 105.613,92.718 105.613,92.788 105.613,92.858 105.613,92.928 105.613,92.999 106.176,92.999
  region: 107.019,82.806 107.16,82.806 107.16,82.736 107.23,82.736 107.23,82.665 107.23,82.595 107.301,82.595 107.301,82.525 107.301,82.454 107.301,82.384 107.301,82.314 107.371,82.314 107.371,82.244 107.301,82.244 107.301,82.173 107.301,82.103 107.301,82.033 107.23,82.033 107.23,81.962 107.23,81.892 107.16,81.892 107.16,81.822 107.019,81.822 107.019,81.751 106.879,81.751 106.879,81.681 106.457,81.681 106.457,81.751 106.457,81.822 106.457,81.892 106.457,81.962 106.457,82.033 106.457,82.103 106.457,82.173 106.457,82.244 106.457,82.314 106.457,82.384 106.457,82.454 106.457,82.525 106.457,82.595 106.457,82.665 106.457,82.736 106.457,82.806 106.457,82.876 107.019,82.876
  region: 112.081,85.126 112.292,85.126 112.292,85.055 112.362,85.055 112.362,84.985 112.362,84.915 112.432,84.915 112.432,84.844 112.432,84.774 112.432,84.704 112.432,84.634 112.432,84.563 112.502,84.563 112.502,84.493 112.432,84.493 112.432,84.423 112.432,84.352 112.432,84.282 112.362,84.282 112.362,84.212 112.292,84.212 112.292,84.142 112.221,84.142 112.221,84.071 111.87,84.071 111.87,84.142 111.729,84.142 111.729,84.212 111.659,84.212 111.659,84.282 111.589,84.282 111.589,84.352 111.589,84.423 111.589,84.493 111.518,84.493 111.518,84.563 111.518,84.634 111.518,84.704 111.589,84.704 111.589,84.774 111.589,84.844 111.589,84.915 111.589,84.985 111.659,84.985 111.659,85.055 111.729,85.055 111.729,85.126 111.94,85.126 111.94,85.196 112.081,85.196
  region: 112.643,81.892 112.643,81.822 112.643,81.751 112.643,81.681 112.643,81.611 112.643,81.541 112.643,81.47 112.643,81.4 112.643,81.33 112.643,81.259 112.643,81.189 112.643,81.119 112.643,81.049 112.713,81.049 112.713,80.978 113.487,80.978 113.487,80.908 113.487,80.838 113.416,80.838 113.416,80.767 113.416,80.697 113.346,80.697 113.346,80.627 113.346,80.556 113.276,80.556 113.276,80.486 113.205,80.486 113.205,80.416 113.065,80.416 113.065,80.346 112.432,80.346 112.432,80.416 112.432,80.486 112.432,80.556 112.432,80.627 112.432,80.697 112.432,80.767 112.432,80.838 112.432,80.908 112.432,80.978 112.432,81.049 112.432,81.119 112.432,81.189 112.432,81.259 112.432,81.33 112.432,81.4 112.432,81.47 112.432,81.541 112.432,81.611 112.432,81.681 112.432,81.751 112.432,81.822 112.432,81.892 112.432,81.962 112.643,81.962
  text "878/5" at 70.612,186.436 h2.03
  text "1" at 70.612,183.642 h2.03
  text "LIGO D2000592-v2" at 65.786,78.486 h2.03
Dummy Ground:
  text "878/5" at 70.866,186.944 h2.03
  text "2" at 72.39,183.642 h2.03
  text "LIGO D2000592-v2" at 65.786,78.486 h2.03
Dummy Power:
  text "878/5" at 70.866,186.944 h2.03
  text "3" at 74.676,183.642 h2.03
  text "LIGO D2000592-v2" at 65.786,78.486 h2.03
Bottom Layer:
  text "878/5" at 79.248,186.944 h2.03
  text "4" at 77.216,183.642 h2.03
  text "LIGO D2000592-v2" at 93.218,78.74 h2.03

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w0.254: 96.266,149.987 96.266,152.527 ; 127.254,96.266 127.254,96.52 127.762,97.028
  text "LIGO D2000592-v2" at 65.786,78.486 h2.03
Bottom Overlay:
  text "LIGO D2000592-v2" at 93.218,78.74 h2.03
Mechanical 2:
  lines w0.254: 50.8,91.313 50.8,94.234 ; 50.8,94.209 68.809,94.209 68.809,76.2 ; 50.8,172.187 68.809,172.187 68.809,190.195 ; 50.8,172.212 50.8,175.006 ; 65.913,76.2 68.834,76.2 ; 65.913,190.195 68.834,190.195 ; 146.787,76.2 146.787,94.209 164.795,94.209 ; 146.787,190.195 146.787,172.187 164.795,172.187 ; 146.812,76.2 149.733,76.2 ; 146.812,190.195 149.657,190.195 ; 164.795,91.313 164.795,94.234 ; 164.795,172.212 164.795,175.006 ; 89.789,124.206 125.806,124.206 125.806,142.189 89.789,142.189 89.789,124.206
Mechanical 4:
  lines w0.254: 65.888,190.195 ccw(c65.888,175.108) 50.8,175.108 50.8,91.288 ccw(c65.888,91.288) 65.888,76.2 149.708,76.2 ccw(c149.708,91.288) 164.795,91.288 164.795,175.108 ccw(c149.708,175.108) 149.708,190.195 65.913,190.195
Mechanical 10:
  lines w0.508: 88.9,74.93 164.465,74.93 166.37,76.835 166.37,156.845 ; 89.408,74.93 80.772,74.93 80.01,75.692 80.01,105.156 83.439,108.585 136.525,108.585 141.605,113.665 141.605,115.57 140.97,116.205 78.74,116.205 77.47,117.475 77.47,122.555 78.105,123.19 142.24,123.19 143.51,124.46 143.51,139.065 142.24,140.335 90.17,140.335 83.82,133.985 78.74,133.985 78.105,134.62 78.105,145.415 78.74,146.05 142.24,146.05 144.145,147.955 144.145,151.13 142.875,152.4 103.505,152.4 ; 104.775,152.4 74.295,152.4 71.755,154.94 71.755,163.195 76.2,167.64 88.265,167.64 111.76,167.64 111.76,191.135
Mechanical 11:
  lines w0.254: 69.3,76.7 69.3,189.7 ; 69.3,95.2 146.3,95.2 ; 69.3,171.2 146.3,171.2 ; 146.3,76.7 146.3,189.7
Mechanical 16:
  lines w0.254: 88.265,101.6 88.265,99.695 97.155,99.695 97.155,101.6 ; 88.265,102.87 88.265,104.775 97.155,104.775 97.155,102.87 ; 118.745,101.6 118.745,99.695 127.635,99.695 127.635,101.6 ; 118.745,102.87 118.745,104.775 127.635,104.775 127.635,102.87